# IAR project TLE9879QXA40_BLDC_FOC_SENSORLESS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; emo
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: TLE9879QXA40_BLDC_FOC_SENSORLESS.hex
  ILINK.IlinkOutputFile: TLE9879QXA40_BLDC_FOC_SENSORLESS.out
  ILINK.IlinkKeepSymbols: p_NACNAD
  ILINK.IlinkIcfFile: TLE9879QXA40.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group app
    app/: Main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device.SDK WDT1
    RTE/Device/TLE9879QXA40/: wdt1.c wdt1.h
  group CMSIS-Pack/Device.SDK SCU
    RTE/Device/TLE9879QXA40/: scu.c scu.h
  group CMSIS-Pack/Device.SDK PORT
    RTE/Device/TLE9879QXA40/: port.c port.h
  group CMSIS-Pack/Device.SDK PMU
    RTE/Device/TLE9879QXA40/: pmu.c pmu.h
  group CMSIS-Pack/Device.SDK MON
    RTE/Device/TLE9879QXA40/: mon.c mon.h
  group CMSIS-Pack/Device.SDK LIN
    RTE/Device/TLE9879QXA40/: lin.c lin.h
  group CMSIS-Pack/Device.SDK ISR
    RTE/Device/TLE9879QXA40/: isr.c isr.h
  group CMSIS-Pack/Device.SDK INT
    RTE/Device/TLE9879QXA40/: int.c int.h
  group CMSIS-Pack/Device.SDK GPT12E
    RTE/Device/TLE9879QXA40/: gpt12e.c gpt12e.h
  group CMSIS-Pack/Device.SDK CCU6
    RTE/Device/TLE9879QXA40/: ccu6.c ccu6.h
  group CMSIS-Pack/Device.SDK BOOTROM
    RTE/Device/TLE9879QXA40/: bootrom.c bootrom.h
  group CMSIS-Pack/Device.SDK BDRV
    RTE/Device/TLE9879QXA40/: bdrv.c bdrv.h
  group CMSIS-Pack/Device.SDK ADC2
    RTE/Device/TLE9879QXA40/: adc2.c adc2.h
  group CMSIS-Pack/Device.SDK ADC1
    RTE/Device/TLE9879QXA40/: adc1.c adc1.h
  group CMSIS-Pack/Device Startup
    RTE/Device/TLE9879QXA40/: cmsis_misra.h eval_board.h sfr_access.h startup_tle987x.s system_tle987x.c system_tle987x.h tle987x.h tle_device.c tle_device.h tle_variants.h types.h
  group CMSIS-Pack/Device ConfigWizard_v2
    RTE/Device/TLE9879QXA40/: adc1_defines.h adc2_defines.h bdrv_defines.h bsl_defines.h ccu6_defines.h config.icwp csa_defines.h dma_defines.h gpt12e_defines.h ICW_TLE987x.xml int_defines.h isr_defines.h lin_defines.h mon_defines.h pmu_defines.h port_defines.h scu_defines.h ssc_defines.h timer2x_defines.h timer3_defines.h TLE987x.mig TLE987x.svd uart_defines.h
  group CMSIS-Pack/Device.SDK CSA
    RTE/Device/TLE9879QXA40/: csa.c csa.h
  group emo
    emo/: Emo.c Emo.h Emo_cfg.c Emo_RAM.c Emo_RAM.h Emo_speed_api.c Mat.h Table.c Table.h
