# Keil uVision project TLE9879QXA40_BLDC_FOC_SENSORLESS.uvprojx, settings and files
target TLE9879_EvalKit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TLE9879QXA40 Infineon
  pack: Infineon.TLE987x_DFP.1.5.0
  cpu: IRAM(0x18000018,0x17E8) IRAM2(0x18000000,0x10) IROM(0x11000000,0x1EFFC) IROM2(0x1101EFFC,0x1004) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Sensorless_FOC
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\emo
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x1effc
  memory RVCT5: ROM 0x1101effc size 0x1004
  memory RVCT9: RAM 0x18000018 size 0x17e8
  memory RVCT10: RAM 0x18000000 size 0x10
  link misc: --diag_suppress L6918
  group App
    ./app/: Main.c
  group Emo
    ./emo/: Emo.c Emo_cfg.c Emo_RAM.c Emo_speed_api.c Table.c
software components: CMSIS:CORE 5.1.2, Device:BF-Stepping 0.0.1, Device:ConfigWizard_v2 2.1.12, Device:SDK:ADC1 0.2.4, Device:SDK:ADC2 0.1.9, Device:SDK:BDRV 0.4.3, Device:SDK:BOOTROM 0.2.6, Device:SDK:CCU6 0.2.9, Device:SDK:CSA 0.1.4, Device:SDK:GPT12E 0.1.8, Device:SDK:INT 0.1.8, Device:SDK:ISR 0.2.5, Device:SDK:LIN 0.1.7, Device:SDK:MON 0.1.4, Device:SDK:PMU 0.1.7, Device:SDK:PORT 0.5.5, Device:SDK:SCU 0.3.6, Device:SDK:WDT1 0.2.8, Device:Startup 1.0.0
